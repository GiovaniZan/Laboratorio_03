<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Exercicio16\Exercicio16.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exercicio17\Exercicio17.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exercicio18\Exercicio18.ewp</path>
    </project>
    <batchBuild />
</workspace>
